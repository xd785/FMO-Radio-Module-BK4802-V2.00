# Keil uVision project nfm-module.uvprojx, settings and files
target nfm-module-v1 (6070000::V6.7::.\ARMCLANG)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.1.7
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: nfm-module +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,PY32F030x8
  c include: ..\CMSIS\Device\PY32F0xx\Include;..\CMSIS\Device\PY32F0xx\Source;..\CMSIS\Include;..\CMSIS;..\common;..\hal;..\hal\PY32F0xx_HAL_Driver\Inc;..\hal\PY32F0xx_HAL_Driver\Src;..\support;..\user;..\components;..\components\easylogger\inc;..\components\easylogger\src;..\components\millis;..\components\port;..\components\RTT\RTT;..\components\RTT\Config;..\components\basic\math;..\components\basic\ring;..\components\basic\string;..\components\algorithm\PID;..\components\Sch51;..\components\softI2C;..\device;..\user\atTask;..\user\radio
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ../common/: system_py32f0xx.c startup_py32f030xx.s
  group Hal
    ../hal/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c
  group Components
    ../components/easylogger/src/: elog.c elog_utils.c
    ../components/port/: elog_port.c millis.c
    ../components/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../components/basic/math/: xMath.c
    ../components/basic/ring/: xRingBuf.c
    ../components/basic/string/: xString.c
    ../components/Sch51/: Sch51.c
    ../components/algorithm/PID/: pid.c
    ../components/softI2C/: softI2C.c
  group Device
    ../device/: osTimer.c systemClock.c
  group User
    ../user/: at.c atCommand.c BK4802.c components.c led.c boot.c main.c py32f0xx_it.c radio.c raidoConvert.c speaker.c misc.c antennaPath.c jumper.c wdt.c
software components: CMSIS:CORE 5.5.0
